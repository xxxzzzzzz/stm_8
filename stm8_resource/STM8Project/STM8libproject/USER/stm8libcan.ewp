# IAR project stm8libcan.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208RB STM8S208RB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\fwlib\inc; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8libcan.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h uart.c
  group fwlib/inc
    ../fwlib/inc/: stm8s.h stm8s_can.h stm8s_clk.h
  group fwlib/src
    ../fwlib/src/: stm8s_can.c stm8s_clk.c
